# Keil uVision project 19S_Pro.uvprojx, settings and files
target rt-thread_stm32f4xx (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-stm32f4xx +hex
  AfterMake: fromelf --bin !L --output  ./bin/19SApp_20231010.bin
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx, HF_20us, LF_50us
  c include: applications;.;drivers;Libraries\CMSIS\Device\ST\STM32F4xx\Include;Libraries\CMSIS\Include;Libraries\STM32F4xx_HAL_Driver\Inc;..\..\include;..\..\libcpu\arm\cortex-m4;..\..\libcpu\arm\common;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\finsh;..\..\libreg
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0xe0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\mystm32_rom.sct
  group Applications
    applications/: main.c
    ./applications/: UART_Protocol.c UART_DEVICE.c UART_Parameters.c UART_grade.c Ultrason_Tran.c Ultrason_RCV.c Ultrason_Airth.c Ultrason_Cal.c Auto_Adjust.c
  group Drivers
    drivers/: board.c drv_usart.c stm32f4xx_it.c
    ./drivers/: adc.c DAC.c Time.c Cir_Queue.c Regtime.c iwdg.c
  group CMSIS
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group STM32F4xx_HAL_Driver
    Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_wwdg.c
    ./Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_tim_ex.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c
  group Reg_lib
    ../../libreg/: S230D-RegisterParse_No.lib
  group Document
    ./applications/: Readme.txt
